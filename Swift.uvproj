# Keil uVision project Swift.uvproj, settings and files
target Swift (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Swift +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Driver\CoreDriver\Cpu;.\Driver\CoreDriver\Ram\INC;.\Driver\CoreDriver\Sys\INC;.\Driver\CoreDriver\Timer\INC;.\Driver\CoreDriver\Uart\INC;.\Driver\HARDWARE\LED;.\Driver\HARDWARE\TIMER;.\Driver\HARDWARE\SRAM;.\Driver\STM32F10x_FWLib\inc;.\kernel\Core\INC;.\kernel\Core;.\kernel\Thread\INC;.\kernel\Ipc\INC;.\kernel\Memery\INC;.\kernel\Configs;.\kernel\Hal\core;.\Driver\CoreDriver\Timer;.\kernel\Start\INC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CoreDriver_CPU
    ./Driver/CoreDriver/Cpu/: os_cpu_a.asm core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Kernel_Core
    ./kernel/Core/: Inter_Handler.c K_Core.c SwiftOS.h SwiftOS.c
  group Kernel_Memery
    ./kernel/Memery/: K_Malloc.c
    ./kernel/Memery/INC/: K_Malloc.h
  group Kernel_Thread
    ./kernel/Thread/: K_TDS_Operate.c K_Thread.c Mutex.c Semaphore.c Time.c
    ./kernel/Thread/INC/: K_TDS_Operate.h K_Thread.h Time.h Mutex.h
  group Kernel_Ipc
    ./kernel/Ipc/: BroadCast.c Event.c MemShare.c Message.c
  group Kernel_Hal_Core
    ./kernel/Hal/core/: K_Cpu_Core.c K_Cpu.h K_Cpu_Core.h
  group Kernel_Configs
    ./kernel/Configs/: K_CFG.h
  group CoreDriver_Ram
    ./Driver/CoreDriver/Ram/: malloc.c
    ./Driver/CoreDriver/Ram/INC/: malloc.h
    ./Driver/HARDWARE/SRAM/: sram.c sram.h
  group CoreDiver_Timer
    ./Driver/CoreDriver/Timer/: delay.c
    ./Driver/CoreDriver/Timer/INC/: delay.h
  group CoreDriver_Sys
    ./Driver/CoreDriver/Sys/: sys.c
    ./Driver/CoreDriver/Sys/INC/: sys.h
  group Kernel_Start
    ./kernel/Start/: Start.c
    ./kernel/Start/INC/: Start.h
  group Main
    ./kernel/: main.c
  group Iner_Driver
    ./Driver/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Iner_Driver_INC
    ./Driver/STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Outer_Driver_INC
    ./Driver/HARDWARE/LED/: led.h
    ./Driver/CoreDriver/Uart/INC/: usart.h
  group Outer_Driver
    ./Driver/HARDWARE/LED/: led.c
    ./Driver/CoreDriver/Uart/: usart.c
